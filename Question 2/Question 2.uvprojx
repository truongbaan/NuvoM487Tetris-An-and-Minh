# Keil uVision project Question 2.uvprojx, settings and files
target Question 2 (6220000::V6.22::ARMCLANG)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: Question 2
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: .\Library\CMSIS\Include;.\Library\Device\Nuvoton\M480\Include;.\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./Library/Device/Nuvoton/M480/Source/: system_M480.c
    ./Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Library
    ./Library/StdDriver/src/: clk.c eadc.c ebi.c gpio.c retarget.c sys.c timer.c uart.c
  group User
    ./: block.c EBI_LCD_Module.c image.c image_16x32.c main.c startScreenImage_RGB565.c
